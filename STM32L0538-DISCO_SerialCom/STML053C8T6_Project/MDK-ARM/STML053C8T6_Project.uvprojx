# Keil uVision project STML053C8T6_Project.uvprojx, settings and files
target STML053C8T6_Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L053C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: STML053C8T6_Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L053xx
  c include: ../Core/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;../UartCom
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l053xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c iwdg.c usart.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_iwdg.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group UartCom
    ../UartCom/: UartCom.c UartCom.h
software components: CMSIS:CORE 5.5.0
